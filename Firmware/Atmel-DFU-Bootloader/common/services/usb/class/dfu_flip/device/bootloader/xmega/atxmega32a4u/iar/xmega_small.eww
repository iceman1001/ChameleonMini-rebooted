<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\xmega_small.ewp</path>
	</project>
</workspace>
